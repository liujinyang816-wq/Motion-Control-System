# Keil uVision project SOEM_STM32H7.uvprojx, settings and files
target SOEM_STM2H7 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x000E0000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: SOEM_H7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c misc: --gnu
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\User\Inc;..\ETHERCAT;..\HARDWARE\RS485;..\HARDWARE\FDCAN;..\HARDWARE\MODBUS;..\Middle\FreeRTOS\portable\RVDS\ARM_CM4F;..\Middle\FreeRTOS\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\SOEM_H7_custom.sct
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: system_stm32h7xx.c main.c gpio.c eth.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
    ../Core/Inc/: FreeRTOSConfig.h
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_fdcan.c
  group user
    ../User/Src/: DM9161.c DM9000.c bsp_timer.c motion_profile.c param_store.c motion_api.c ethercat_slave.c ethercat_task.c serial_cmd.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/FDCAN/: fdcan.c
    ../HARDWARE/MODBUS/: modbus_slave.c
  group ETHERCAT
    ../ETHERCAT/: ethercatbase.c ethercatcoe.c ethercatsoe.c ethercatconfig.c ethercatmain.c ethercatdc.c ethercatprint.c nicdrv.c
  group FreeRTOS/Source
    ../Middle/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Portable
    ../Middle/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../Middle/FreeRTOS/portable/RVDS/MemMang/: heap_4.c
software components: CMSIS:CORE 5.0.1
